## drivers/misc/nunchuk/Kconfig
```kconfig
config NUNCHUK
	tristate "Nunchuk support"
	default n
	help
		This driver provides support for the stupendous Nunchuk driver.
```
